*This is 60 sections ladder circuit
C1 1 0 1pf
R2 1 2 1k
C3 2 0 1pf
R4 2 3 1k
C5 3 0 1pf
R6 3 4 1k
C7 4 0 1pf
R8 4 5 1k
C9 5 0 1pf
R10 5 6 1k
C11 6 0 1pf
R12 6 7 1k
C13 7 0 1pf
R14 7 8 1k
C15 8 0 1pf
R16 8 9 1k
C17 9 0 1pf
R18 9 10 1k
C19 10 0 1pf
R20 10 11 1k
C21 11 0 1pf
R22 11 12 1k
C23 12 0 1pf
R24 12 13 1k
C25 13 0 1pf
R26 13 14 1k
C27 14 0 1pf
R28 14 15 1k
C29 15 0 1pf
R30 15 16 1k
C31 16 0 1pf
R32 16 17 1k
C33 17 0 1pf
R34 17 18 1k
C35 18 0 1pf
R36 18 19 1k
C37 19 0 1pf
R38 19 20 1k
C39 20 0 1pf
R40 20 21 1k
C41 21 0 1pf
R42 21 22 1k
C43 22 0 1pf
R44 22 23 1k
C45 23 0 1pf
R46 23 24 1k
C47 24 0 1pf
R48 24 25 1k
C49 25 0 1pf
R50 25 26 1k
C51 26 0 1pf
R52 26 27 1k
C53 27 0 1pf
R54 27 28 1k
C55 28 0 1pf
R56 28 29 1k
C57 29 0 1pf
R58 29 30 1k
C59 30 0 1pf
R60 30 31 1k
C61 31 0 1pf
R62 31 32 1k
C63 32 0 1pf
R64 32 33 1k
C65 33 0 1pf
R66 33 34 1k
C67 34 0 1pf
R68 34 35 1k
C69 35 0 1pf
R70 35 36 1k
C71 36 0 1pf
R72 36 37 1k
C73 37 0 1pf
R74 37 38 1k
C75 38 0 1pf
R76 38 39 1k
C77 39 0 1pf
R78 39 40 1k
C79 40 0 1pf
R80 40 41 1k
C81 41 0 1pf
R82 41 42 1k
C83 42 0 1pf
R84 42 43 1k
C85 43 0 1pf
R86 43 44 1k
C87 44 0 1pf
R88 44 45 1k
C89 45 0 1pf
R90 45 46 1k
C91 46 0 1pf
R92 46 47 1k
C93 47 0 1pf
R94 47 48 1k
C95 48 0 1pf
R96 48 49 1k
C97 49 0 1pf
R98 49 50 1k
C99 50 0 1pf
R100 50 51 1k
C101 51 0 1pf
R102 51 52 1k
C103 52 0 1pf
R104 52 53 1k
C105 53 0 1pf
R106 53 54 1k
C107 54 0 1pf
R108 54 55 1k
C109 55 0 1pf
R110 55 56 1k
C111 56 0 1pf
R112 56 57 1k
C113 57 0 1pf
R114 57 58 1k
C115 58 0 1pf
R116 58 59 1k
C117 59 0 1pf
R118 59 60 1k
C119 60 0 1pf
R120 60 61 1k
R121 61 0 1k

vin 1 0 dc 0 ac 1
.ac dec 1000 1 10
.plot v(61)
.end
