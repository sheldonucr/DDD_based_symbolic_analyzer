*This is 100 section ladder circuit
R1 1 0 1k
R2 1 2 1k
R3 2 0 1k
R4 2 3 1k
R5 3 0 1k
R6 3 4 1k
R7 4 0 1k
R8 4 5 1k
R9 5 0 1k
R10 5 6 1k
R11 6 0 1k
R12 6 7 1k
R13 7 0 1k
R14 7 8 1k
R15 8 0 1k
R16 8 9 1k
R17 9 0 1k
R18 9 10 1k
R19 10 0 1k
R20 10 11 1k
R21 11 0 1k
R22 11 12 1k
R23 12 0 1k
R24 12 13 1k
R25 13 0 1k
R26 13 14 1k
R27 14 0 1k
R28 14 15 1k
R29 15 0 1k
R30 15 16 1k
R31 16 0 1k
R32 16 17 1k
R33 17 0 1k
R34 17 18 1k
R35 18 0 1k
R36 18 19 1k
R37 19 0 1k
R38 19 20 1k
R39 20 0 1k
R40 20 21 1k
R41 21 0 1k
R42 21 22 1k
R43 22 0 1k
R44 22 23 1k
R45 23 0 1k
R46 23 24 1k
R47 24 0 1k
R48 24 25 1k
R49 25 0 1k
R50 25 26 1k
R51 26 0 1k
R52 26 27 1k
R53 27 0 1k
R54 27 28 1k
R55 28 0 1k
R56 28 29 1k
R57 29 0 1k
R58 29 30 1k
R59 30 0 1k
R60 30 31 1k
R61 31 0 1k
R62 31 32 1k
R63 32 0 1k
R64 32 33 1k
R65 33 0 1k
R66 33 34 1k
R67 34 0 1k
R68 34 35 1k
R69 35 0 1k
R70 35 36 1k
R71 36 0 1k
R72 36 37 1k
R73 37 0 1k
R74 37 38 1k
R75 38 0 1k
R76 38 39 1k
R77 39 0 1k
R78 39 40 1k
R79 40 0 1k
R80 40 41 1k
R81 41 0 1k
R82 41 42 1k
R83 42 0 1k
R84 42 43 1k
R85 43 0 1k
R86 43 44 1k
R87 44 0 1k
R88 44 45 1k
R89 45 0 1k
R90 45 46 1k
R91 46 0 1k
R92 46 47 1k
R93 47 0 1k
R94 47 48 1k
R95 48 0 1k
R96 48 49 1k
R97 49 0 1k
R98 49 50 1k
R99 50 0 1k
R100 50 51 1k
R101 51 0 1k
R102 51 52 1k
R103 52 0 1k
R104 52 53 1k
R105 53 0 1k
R106 53 54 1k
R107 54 0 1k
R108 54 55 1k
R109 55 0 1k
R110 55 56 1k
R111 56 0 1k
R112 56 57 1k
R113 57 0 1k
R114 57 58 1k
R115 58 0 1k
R116 58 59 1k
R117 59 0 1k
R118 59 60 1k
R119 60 0 1k
R120 60 61 1k
R121 61 0 1k
R122 61 62 1k
R123 62 0 1k
R124 62 63 1k
R125 63 0 1k
R126 63 64 1k
R127 64 0 1k
R128 64 65 1k
R129 65 0 1k
R130 65 66 1k
R131 66 0 1k
R132 66 67 1k
R133 67 0 1k
R134 67 68 1k
R135 68 0 1k
R136 68 69 1k
R137 69 0 1k
R138 69 70 1k
R139 70 0 1k
R140 70 71 1k
R141 71 0 1k
R142 71 72 1k
R143 72 0 1k
R144 72 73 1k
R145 73 0 1k
R146 73 74 1k
R147 74 0 1k
R148 74 75 1k
R149 75 0 1k
R150 75 76 1k
R151 76 0 1k
R152 76 77 1k
R153 77 0 1k
R154 77 78 1k
R155 78 0 1k
R156 78 79 1k
R157 79 0 1k
R158 79 80 1k
R159 80 0 1k
R160 80 81 1k
R161 81 0 1k
R162 81 82 1k
R163 82 0 1k
R164 82 83 1k
R165 83 0 1k
R166 83 84 1k
R167 84 0 1k
R168 84 85 1k
R169 85 0 1k
R170 85 86 1k
R171 86 0 1k
R172 86 87 1k
R173 87 0 1k
R174 87 88 1k
R175 88 0 1k
R176 88 89 1k
R177 89 0 1k
R178 89 90 1k
R179 90 0 1k
R180 90 91 1k
R181 91 0 1k
R182 91 92 1k
R183 92 0 1k
R184 92 93 1k
R185 93 0 1k
R186 93 94 1k
R187 94 0 1k
R188 94 95 1k
R189 95 0 1k
R190 95 96 1k
R191 96 0 1k
R192 96 97 1k
R193 97 0 1k
R194 97 98 1k
R195 98 0 1k
R196 98 99 1k
R197 99 0 1k
R198 99 100 1k
R199 100 0 1k
R200 100 101 1k
R201 101 0 1k

vin 1 0 dc 0 ac 1
.ac dec 1000 1  10
.plot vdb(101)
.end
