*This is 100 section ladder circuit
R1 1 0 1.0
R2 1 2 1.0
c3 2 0 1.0
R4 2 3 1.0
R5 3 0 1.0
c6 3 4 1.0
R7 4 0 1.0
R8 4 5 1.0
c9 5 0 1.0
R10 5 6 1.0
R11 6 0 1.0
R12 6 7 1.0
c13 7 0 1.0
R14 7 8 1.0
R15 8 0 1.0
c16 8 9 1.0
R17 9 0 1.0
R18 9 10 1.0
c19 10 0 1.0
R20 10 11 1.0
R21 11 0 1.0
R22 11 12 1.0
c23 12 0 1.0
R24 12 13 1.0
c25 13 0 1.0
R26 13 14 1.0
R27 14 0 1.0
c28 14 15 1.0
R29 15 0 1.0
R30 15 16 1.0
c31 16 0 1.0
R32 16 17 1.0
R33 17 0 1.0
R34 17 18 1.0
c35 18 0 1.0
R36 18 19 1.0
c37 19 0 1.0
c38 19 20 1.0
R39 20 0 1.0
c40 20 21 1.0
R41 21 0 1.0
R42 21 22 1.0
R43 22 0 1.0
R44 22 23 1.0
c45 23 0 1.0
R46 23 24 1.0
R47 24 0 1.0
c48 24 25 1.0
R49 25 0 1.0
R50 25 26 1.0
c51 26 0 1.0
R52 26 27 1.0
R53 27 0 1.0
R54 27 28 1.0
c55 28 0 1.0
R56 28 29 1.0
R57 29 0 1.0
R58 29 30 1.0
c59 30 0 1.0
R60 30 31 1.0
R61 31 0 1.0
R62 31 32 1.0
c63 32 0 1.0
R64 32 33 1.0
R65 33 0 1.0
c66 33 34 1.0
R67 34 0 1.0
R68 34 35 1.0
c69 35 0 1.0
R70 35 36 1.0
R71 36 0 1.0
c72 36 37 1.0
R73 37 0 1.0
R74 37 38 1.0
R75 38 0 1.0
R76 38 39 1.0
c77 39 0 1.0
R78 39 40 1.0
R79 40 0 1.0
R80 40 41 1.0
R81 41 0 1.0
c82 41 42 1.0
R83 42 0 1.0
R84 42 43 1.0
R85 43 0 1.0
R86 43 44 1.0
c87 44 0 1.0
R88 44 45 1.0
R89 45 0 1.0
R90 45 46 1.0
c91 46 0 1.0
R92 46 47 1.0
R93 47 0 1.0
R94 47 48 1.0
R95 48 0 1.0
c96 48 49 1.0
R97 49 0 1.0
R98 49 50 1.0
R99 50 0 1.0
R100 50 51 1.0
c101 51 0 1.0
R102 51 52 1.0
R103 52 0 1.0
R104 52 53 1.0
R105 53 0 1.0
c106 53 54 1.0
R107 54 0 1.0
R108 54 55 1.0
R109 55 0 1.0
c110 55 56 1.0
R111 56 0 1.0
R112 56 57 1.0
c113 57 0 1.0
R114 57 58 1.0
R115 58 0 1.0
R116 58 59 1.0
R117 59 0 1.0
R118 59 60 1.0
R119 60 0 1.0
R120 60 61 1.0
c121 61 0 1.0
R122 61 62 1.0
c123 62 0 1.0
R124 62 63 1.0
c125 63 0 1.0
R126 63 64 1.0
R127 64 0 1.0
c128 64 65 1.0
R129 65 0 1.0
c130 65 66 1.0
R131 66 0 1.0
c132 66 67 1.0
R133 67 0 1.0
c134 67 68 1.0
R135 68 0 1.0
R136 68 69 1.0
c137 69 0 1.0
R138 69 70 1.0
R139 70 0 1.0
c140 70 71 1.0
R141 71 0 1.0
R142 71 72 1.0
c143 72 0 1.0
R144 72 73 1.0
R145 73 0 1.0
c146 73 74 1.0
R147 74 0 1.0
c148 74 75 1.0
R149 75 0 1.0
R150 75 76 1.0
c151 76 0 1.0
R152 76 77 1.0
c153 77 0 1.0
R154 77 78 1.0
R155 78 0 1.0
c156 78 79 1.0
R157 79 0 1.0
R158 79 80 1.0
c159 80 0 1.0
R160 80 81 1.0
c161 81 0 1.0
R162 81 82 1.0
R163 82 0 1.0
c164 82 83 1.0
R165 83 0 1.0
c166 83 84 1.0
R167 84 0 1.0
R168 84 85 1.0
c169 85 0 1.0
R170 85 86 1.0
c171 86 0 1.0
R172 86 87 1.0
R173 87 0 1.0
c174 87 88 1.0
R175 88 0 1.0
R176 88 89 1.0
c177 89 0 1.0
R178 89 90 1.0
c179 90 0 1.0
c180 90 91 1.0
R181 91 0 1.0
R182 91 92 1.0
c183 92 0 1.0
R184 92 93 1.0
c185 93 0 1.0
R186 93 94 1.0
c187 94 0 1.0
R188 94 95 1.0
c189 95 0 1.0
R190 95 96 1.0
c191 96 0 1.0
R192 96 97 1.0
R193 97 0 1.0
c194 97 98 1.0
R195 98 0 1.0
R196 98 99 1.0
R197 99 0 1.0
c198 99 100 1.0
R199 100 0 1.0
R200 100 101 1.0
c201 101 0 1.0

vin 1 0 dc 0 ac 1
.ac dec 1000 1  10
.plot vdb(101)
.end
