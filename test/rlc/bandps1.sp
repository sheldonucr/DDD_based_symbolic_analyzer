*The sample of bandpass
v1 1 0 DC 0 AC 1
r1 1 2 10k
c1 2 3 1u
c2 3 0 0.00001
r2 3 0 1
.AC DEC 100 0.0001 10e7
