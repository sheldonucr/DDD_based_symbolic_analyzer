CMOS cascode opamp from Q. Yu paper in ICCAD 1994
*
*m1 16 5 13 3 pmos w=80.00u l=5.00u ad=480.00p as=280.00p pd=184.00u
*+  ps=94.00u
gmm1 16 13 5 13 9.380000e-04
gmbm1 16 13 0 13 4.880000e-05
rdsm1 16 13 0.184713e+04
cbdm1 0 16 4.290000e-14
cbsm1 0 13 3.370000e-14
cgsm1 5 13 1.180000e-13
cgdm1 5 16 0.000000e+00
cgbm1 5 0 0.000000e+00

*m2 17 6 13 3 pmos w=80.00u l=5.00u ad=280.00p as=280.00p pd=94.00u
*+  ps=94.00u
gmm2 17 13 6 13 9.390000e-04
gmbm2 17 13 0 13 4.890000e-05
rdsm2 17 13 3.174603e+04
cbdm2 0 17 2.460000e-14
cbsm2 0 13 3.370000e-14
cgsm2 6 13 1.180000e-13
cgdm2 6 17 0.000000e+00
cgbm2 6 0 0.000000e+00

*m3 16 12 4 4 nmos w=300.00u l=5.00u ad=1800.00p as=1050.00p
*+  pd=624.00u ps=314.00u
gmm3 16 0 12 0 4.810000e-03
gmbm3 16 0 0 0 2.020000e-03
rdsm3 16 0 1.203369e+04
cbdm3 0 16 7.170000e-13
cbsm3 0 0 1.110000e-12
cgsm3 12 0 4.350000e-13
cgdm3 12 16 0.000000e+00
cgbm3 12 0 0.000000e+00

*m4 17 12 4 4 nmos w=300.00u l=5.00u ad=1050.00p as=1050.00p
*+  pd=314.00u ps=314.00u
gmm4 17 0 12 0 4.810000e-03
gmbm4 17 0 0 0 2.020000e-03
rdsm4 17 0 1.206273e+04
cbdm4 0 17 3.880000e-13
cbsm4 0 0 1.110000e-12
cgsm4 12 0 4.350000e-13
cgdm4 12 17 0.000000e+00
cgbm4 12 0 0.000000e+00

c1 5 6 1.9857e-15
c2 16 0 6.5607e-15

*m5 13 9 3 3 pmos w=380.00u l=10.00u ad=1330.00p as=2280.00p
*+  pd=394.00u ps=784.00u
gmm5 13 0 9 0 1.900000e-03
gmbm5 13 0 0 0 2.270000e-04
rdsm5 13 0 3.257329e+04
cbdm5 0 13 1.580000e-13
cbsm5 0 0 5.740000e-13
cgsm5 9 0 1.140000e-12
cgdm5 9 13 0.000000e+00
cgbm5 9 0 0.000000e+00

*mn 15 11 16 4 nmos w=150.00u l=5.00u ad=600.00p as=600.00p pd=220.00u
*+  ps=220.00u
gmmn 15 16 11 16 2.680000e-03
gmbmn 15 16 0 16 4.800000e-04
rdsmn 15 16 2.114165e+04
cbdmn 0 15 1.790000e-13
cbsmn 0 16 2.460000e-13
cgsmn 11 16 2.180000e-13
cgdmn 11 15 0.000000e+00
cgbmn 11 0 0.000000e+00
cgb 11 0 7.80378e-15
cgd 11 15 4.13687e-15

*m6 7 11 17 4 nmos w=150.00u l=5.00u ad=600.00p as=600.00p pd=220.00u
*+  ps=220.00u
gmm6 7 17 11 17 2.720000e-03
gmbm6 7 17 0 17 4.870000e-04
rdsm6 7 17 2.469136e+04
cbdm6 0 7 1.650000e-13
cbsm6 0 17 2.450000e-13
cgsm6 11 17 2.180000e-13
cgdm6 11 7 0.000000e+00
cgbm6 11 0 0.000000e+00

c3 11 0 7.80378e-15
c4 11 7 4.13687e-15

*m7 16 16 12 4 nmos w=10.00u l=2.50u ad=77.50p as=77.50p pd=35.50u
*+  ps=35.50u
gmm7 16 12 16 12 1.550000e-04
gmbm7 16 12 0 12 3.460000e-05
rdsm7 16 12 2.272727e+05
cbdm7 0 16 3.600000e-14
cbsm7 0 12 4.770000e-14
cgsm7 16 12 6.840000e-15
cgdm7 16 16 0.000000e+00
cgbm7 16 0 0.000000e+00

c5 16 0 3.19403e-15

*m12 17 17 12 4 nmos w=10.00u l=2.50u ad=77.50p as=77.50p pd=35.50u
*+  ps=35.50u
gmm12 17 12 17 12 1.610000e-04
gmbm12 17 12 0 12 3.590000e-05
rdsm12 17 12 2.136752e+05
cbdm12 0 17 3.590000e-14
cbsm12 0 12 4.770000e-14
cgsm12 17 12 6.840000e-15
cgdm12 17 17 0.000000e+00
cgbm12 17 0 0.000000e+00

c7 17 0 3.19403e-15

*m13 9 9 3 3 pmos w=40.00u l=10.00u ad=240.00p as=140.00p pd=92.00u
*+  ps=47.00u
gmm13 9 0 9 0 1.970000e-04
gmbm13 9 0 0 0 2.410000e-05
rdsm13 9 0 3.039514e+05
cbdm13 0 9 3.180000e-14
cbsm13 0 0 3.520000e-14
cgsm13 9 0 1.200000e-13
cgdm13 9 9 0.000000e+00
cgbm13 9 0 0.000000e+00

*m14 11 9 3 3 pmos w=40.00u l=10.00u ad=240.00p as=140.00p pd=92.00u
*+  ps=47.00u
gmm14 11 0 9 0 2.110000e-04
gmbm14 11 0 0 0 2.560000e-05
rdsm14 11 0 3.267974e+05
cbdm14 0 11 2.290000e-14
cbsm14 0 0 3.520000e-14
cgsm14 9 0 1.200000e-13
cgdm14 9 11 0.000000e+00
cgbm14 9 0 0.000000e+00

*m15 12 4 9 3 pmos w=5.00u l=18.50u ad=30.00p as=30.00p pd=22.00u
*+  ps=22.00u
gmm15 12 9 0 9 4.460000e-05
gmbm15 12 9 0 9 3.370000e-06
rdsm15 12 9 7.812500e+05
cbdm15 0 12 2.910000e-15
cbsm15 0 9 4.390000e-15
cgsm15 0 9 2.810000e-14
cgdm15 0 12 0.000000e+00
cgbm15 0 0 0.000000e+00

*m16 11 11 4 4 nmos w=6.00u l=10.00u ad=36.00p as=36.00p pd=24.00u
*+  ps=24.00u
gmm16 11 0 11 0 9.330000e-05
gmbm16 11 0 0 0 2.180000e-05
rdsm16 11 0 2.808989e+05
cbdm16 0 11 1.580000e-14
cbsm16 0 0 6.970000e-14
cgsm16 11 0 1.790000e-14
cgdm16 11 11 0.000000e+00
cgbm16 11 0 0.000000e+00

c9 11 0 6.73335e-15

*m17 12 12 4 4 nmos w=40.00u l=5.00u ad=240.00p as=140.00p pd=92.00u
*+  ps=47.00u
gmm17 12 0 12 0 6.060000e-04
gmbm17 12 0 0 0 2.580000e-04
rdsm17 12 0 6.369427e+04
cbdm17 0 12 1.320000e-13
cbsm17 0 0 1.600000e-13
cgsm17 12 0 5.810000e-14
cgdm17 12 12 0.000000e+00
cgbm17 12 0 0.000000e+00

c10 12 0 3.97095e-15

*.equiv vdd = 1
*.equiv gnd = 2
*.equiv avdd = 3
*.equiv avss = 4
*.equiv non = 5
*.equiv inv = 6
*.equiv out = 7
* opamp1 1 2 3 4 5 6 7

*vdd 3 0 dc 12.0v
*vss 0 4 dc 12.0v
*vininv 6 0 dc 0.0v
vinnon 5 0 dc 10.100810mv ac 1.0v 0
rfb 6 7 100k

*.width out=80
*.options list limpts=4000 itl5=0 numdgt=6

*.op

*.dc vinnon 10.100800mv 10.100820mv 0.001uv
*.plot dc v(5) v(7)
*.print dc v(5) v(7)

.ac dec 5 1 800meg
.plot ac vdb(17)
*.plot ac vp(7)
.end
