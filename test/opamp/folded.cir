CMOS cascode opamp from Q. Yu paper in ICCAD 1994
*
m1 16 5 13 3 pmos w=80.00u l=5.00u ad=480.00p as=280.00p pd=184.00u
+  ps=94.00u
m2 17 6 13 3 pmos w=80.00u l=5.00u ad=280.00p as=280.00p pd=94.00u
+  ps=94.00u
m3 16 12 4 4 nmos w=300.00u l=5.00u ad=1800.00p as=1050.00p
+  pd=624.00u ps=314.00u
m4 17 12 4 4 nmos w=300.00u l=5.00u ad=1050.00p as=1050.00p
+  pd=314.00u ps=314.00u
c1 5 6 1.9857e-15
c2 16 3 6.5607e-15
m5 13 9 3 3 pmos w=380.00u l=10.00u ad=1330.00p as=2280.00p
+  pd=394.00u ps=784.00u
mn 15 11 16 4 nmos w=150.00u l=5.00u ad=600.00p as=600.00p pd=220.00u
+  ps=220.00u
cgb 11 4 7.80378e-15
cgd 11 15 4.13687e-15
m6 7 11 17 4 nmos w=150.00u l=5.00u ad=600.00p as=600.00p pd=220.00u
+  ps=220.00u
c3 11 4 7.80378e-15
c4 11 7 4.13687e-15
m8 15 10 18 3 pmos w=200.00u l=5.00u ad=700.00p as=1200.00p
+  pd=214.00u ps=424.00u
m9 7 10 19 3 pmos w=200.00u l=5.00u ad=700.00p as=1200.00p pd=214.00u
+  ps=424.00u
m10 18 14 3 3 pmos w=200.00u l=5.00u ad=1200.00p as=700.00p
+  pd=424.00u ps=214.00u
m11 19 14 3 3 pmos w=200.00u l=5.00u ad=700.00p as=700.00p pd=214.00u
+  ps=214.00u
m7 16 16 12 4 nmos w=10.00u l=2.50u ad=77.50p as=77.50p pd=35.50u
+  ps=35.50u
cp 10 16 1.05904e-15
c5 16 4 3.19403e-15
m12 17 17 12 4 nmos w=10.00u l=2.50u ad=77.50p as=77.50p pd=35.50u
+  ps=35.50u
c6 10 17 1.05904e-15
c7 17 4 3.19403e-15
mp 10 10 3 3 pmos w=14.00u l=10.00u ad=84.00p as=84.00p pd=40.00u
+  ps=40.00u
c8 10 3 6.73335e-15
m13 9 9 3 3 pmos w=40.00u l=10.00u ad=240.00p as=140.00p pd=92.00u
+  ps=47.00u
m14 11 9 3 3 pmos w=40.00u l=10.00u ad=240.00p as=140.00p pd=92.00u
+  ps=47.00u
m15 12 4 9 3 pmos w=5.00u l=18.50u ad=30.00p as=30.00p pd=22.00u
+  ps=22.00u
m16 11 11 4 4 nmos w=6.00u l=10.00u ad=36.00p as=36.00p pd=24.00u
+  ps=24.00u
c9 11 4 6.73335e-15
m17 12 12 4 4 nmos w=40.00u l=5.00u ad=240.00p as=140.00p pd=92.00u
+  ps=47.00u
c10 12 4 3.97095e-15
m18 10 12 4 4 nmos w=40.00u l=5.00u ad=240.00p as=140.00p pd=92.00u
+  ps=47.00u
m19 4 15 14 3 pmos w=100.00u l=7.50u ad=350.00p as=600.00p pd=107.00u
+  ps=212.00u
m20 14 14 3 3 pmos w=300.00u l=2.50u ad=1300.00p as=1300.00p
+  pd=426.00u ps=426.00u
c11 14 3 5.1795e-15

*.equiv vdd = 1
*.equiv gnd = 2
*.equiv avdd = 3
*.equiv avss = 4
*.equiv non = 5
*.equiv inv = 6
*.equiv out = 7
* opamp1 1 2 3 4 5 6 7

*
* model definition
*
.model nmos nmos
+  level = 2            vto = 0.829         uo = 605.2
+    tox = 3.75e-08    nsub = 2.788e+16     xj = 4.752e-07
+     ld = 1.356e-07  delta = 1.621       vmax = 61220
+    nfs = 7.1070e+12    cj = 0.0003352   cjsw = 2.403e-09
+     mj = 0.2841      mjsw = 0.7155        pb = 0.8092
+   cgso = 1.102e-10   cgdo = 1.102e-10   cgbo = 1.387e-10
+  ucrit = 164400      uexp = 0.3855      neff = 0.6787
+    tpg = 1

.model pmos pmos
+  level = 2            vto = -0.844        uo = 199.5
+    tox = 3.75e-08    nsub = 4.371e+15     xj = 3.05e-07
+     ld = 1.033e-07  delta = 1.35        vmax = 235900
+    nfs = 8.2890e+11    cj = 0.0002316   cjsw = 5.872e-11
+     mj = 0.3295      mjsw = 0.1869        pb = 0.7072
+   cgso = 8.39e-11    cgdo = 8.39e-11    cgbo = 1.241e-10
+  ucrit = 116400      uexp = 0.1855      neff = 0.6639
+    tpg = -1
*+ capop=0

vdd 3 0 dc 12.0v
vss 0 4 dc 12.0v
vininv 6 0 dc 0.0v
vinnon 5 0 dc 10.100810mv ac 1.0v 0

.width out=80
*.options list limpts=4000 itl5=0 numdgt=6

*.op

*.dc vinnon 10.100800mv 10.100820mv 0.001uv
*.plot dc v(5) v(7)
*.print dc v(5) v(7)

.ac dec 5 1 800meg
.plot ac vdb(7)
*.plot ac vp(7)
.end
