* Testing Starzyk's example
* Testing opamps
*
*

* format for opamp
* opamp -node out +node

r37 7 5 1.0
r38 6 0 1.0
r39 7 0 1.0
r40 6 8 1.0
*e1 8 0 7 6 1e5

r1_x1 1 102 1
r2_x1 4 108 1
r3+ri1_xo1_x1 102 0 1
r4_x1 108 103 1
r5_x1 103 104 1
r6_x1 104 2 1
c6_x1 104 2 1
r7_x1 2 106 1
c8_x1 106 107 1
r9_x1 107 108 1
rii_xo1_x1 102 108 2e+06
ri2_xo1_x1 108 0 5e+08
g1_xo1_x1 201 0 102 108 2
c1_xo1_x1 201 0 2.66e-05
r1_xo1_x1 201 0 1000
g2_xo1_x1 103 0 201 0 1.33333
rld_xo1_x1 103 0 75
rii_xo2+ri2_xo2_x1 0 104 1.99203e+06
ri1_xo2_x1 0 0 5e+08
g1_xo2_x1 301 0 0 104 2
c1_xo2_x1 301 0 2.66e-05
r1_xo2_x1 301 0 1000
g2_xo2_x1 2 0 301 0 1.33333
rld_xo2_x1 2 0 75
rii_xo3+ri2_xo3_x1 0 106 1.99203e+06
ri1_xo3_x1 0 0 5e+08
g1_xo3_x1 401 0 0 106 2
c1_xo3_x1 401 0 2.66e-05
r1_xo3_x1 401 0 1000
g2_xo3_x1 107 0 401 0 1.33333
rld_xo3_x1 107 0 75
r1_x2 2 202 1
r2_x2 3 208 1
r3+ri1_xo1_x2 202 0 1
r4_x2 208 203 1
r5_x2 203 204 1
r6_x2 204 4 1
c6_x2 204 4 1
r7_x2 4 206 1
c8_x2 206 207 1
r9_x2 207 208 1
rii_xo1_x2 202 208 2e+06
ri2_xo1_x2 208 0 5e+08
g1_xo1_x2 301 0 202 208 2
c1_xo1_x2 301 0 2.66e-05
r1_xo1_x2 301 0 1000
g2_xo1_x2 203 0 301 0 1.33333
rld_xo1_x2 203 0 75
rii_xo2+ri2_xo2_x2 0 204 1.99203e+06
ri1_xo2_x2 0 0 5e+08
g1_xo2_x2 401 0 0 204 2
c1_xo2_x2 401 0 2.66e-05
r1_xo2_x2 401 0 1000
g2_xo2_x2 4 0 401 0 1.33333
rld_xo2_x2 4 0 75
rii_xo3+ri2_xo3_x2 0 206 1.99203e+06
ri1_xo3_x2 0 0 5e+08
g1_xo3_x2 501 0 0 206 2
c1_xo3_x2 501 0 2.66e-05
r1_xo3_x2 501 0 1000
g2_xo3_x2 207 0 501 0 1.33333
rld_xo3_x2 207 0 75
r1_x3 4 302 1
r2_x3 5 308 1
r3+ri1_xo1_x3 302 0 1
r4_x3 308 303 1
r5_x3 303 304 1
r6_x3 304 3 1
c6_x3 304 3 1
r7_x3 3 306 1
c8_x3 306 307 1
r9_x3 307 308 1
rii_xo1_x3 302 308 2e+06
ri2_xo1_x3 308 0 5e+08
g1_xo1_x3 401 0 302 308 2
c1_xo1_x3 401 0 2.66e-05
r1_xo1_x3 401 0 1000
g2_xo1_x3 303 0 401 0 1.33333
rld_xo1_x3 303 0 75
rii_xo2_ri2_xo2_x3 0 304 1.99203e+06
ri1_xo2_x3 0 0 5e+08
g1_xo2_x3 501 0 0 304 2
c1_xo2_x3 501 0 2.66e-05
r1_xo2_x3 501 0 1000
g2_xo2_x3 3 0 501 0 1.33333
rld_xo2_x3 3 0 75
rii_xo3_ri2_xo3_x3 0 306 1.99203e+06
ri1_xo3_x3 0 0 5e+08
g1_xo3_x3 601 0 0 306 2
c1_xo3_x3 601 0 2.66e-05
r1_xo3_x3 601 0 1000
g2_xo3_x3 307 0 601 0 1.33333
rld_xo3_x3 307 0 75
r1_x4 3 402 1
r2_x4 8 408 1
r3_ri1_xo1_x4 402 0 1
r4_x4 408 403 1
r5_x4 403 404 1
r6_x4 404 5 1
c6_x4 404 5 1
r7_x4 5 406 1
c8_x4 406 407 1
r9_x4 407 408 1
rii_xo1_x4 402 408 2e+06
ri2_xo1_x4 408 0 5e+08
g1_xo1_x4 501 0 402 408 2
c1_xo1_x4 501 0 2.66e-05
r1_xo1_x4 501 0 1000
g2_xo1_x4 403 0 501 0 1.33333
rld_xo1_x4 403 0 75
rii_xo2_ri2_xo2_x4 0 404 1.99203e+06
ri1_xo2_x4 0 0 5e+08
g1_xo2_x4 601 0 0 404 2
c1_xo2_x4 601 0 2.66e-05
r1_xo2_x4 601 0 1000
g2_xo2_x4 5 0 601 0 1.33333
rld_xo2_x4 5 0 75
rii_xo3_ri2_xo3_x4 0 406 1.99203e+06
ri1_xo3_x4 0 0 5e+08
g1_xo3_x4 701 0 0 406 2
c1_xo3_x4 701 0 2.66e-05
r1_xo3_x4 701 0 1000
g2_xo3_x4 407 0 701 0 1.33333
rld_xo3_x4 407 0 75
rii_x5 7 6 2e+06
ri1_x5 7 0 5e+08
ri2_x5 6 0 5e+08
g1_x5 501 0 7 6 2
c1_x5 501 0 2.66e-05
r1_x5 501 0 1000
g2_x5 8 0 501 0 1.33333
rld_x5 8 0 75

vin 1 0 dc 0 ac 1
.ac dec 10 1 100meg
.print vdb(8)
.end
