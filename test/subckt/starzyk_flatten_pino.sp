* Testing Starzyk's example
* Testing opamps
*
*

r37 7 5 1.0
r38 6 0 1.0
r39 7 0 1.0
r40 6 8 1.0
*e1 8 0 7 6 1e5

r1_x1 1 102 1
r2_x1 4 108 1
r3_x1 102 0 1
r4_x1 108 103 1
r5_x1 103 104 1
r6_x1 104 2 1
c6_x1 104 2 1
r7_x1 2 106 1
c8_x1 106 107 1
r9_x1 107 108 1
gm1a_xo1_x1 204 203 108 203 5.89e-06
rds1a_xo1_x1 204 203 9.26e+07
cbd1a_xo1_x1 203 204 2.04e-14
cgs1a_xo1_x1 108 203 4.78e-14
gm1b_xo1_x1 205 203 102 203 5.89e-06
rds1b_xo1_x1 205 203 9.26e+07
cbd1b_xo1_x1 203 205 2.04e-14
cgs1b_xo1_x1 102 203 4.78e-14
gm2a_xo1_x1 204 0 204 0 3e-05
rds2a_xo1_x1 204 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo1_x1 0 204 1.1164e-12
gm2b_xo1_x1 205 0 204 0 3e-05
rds2b_xo1_x1 205 0 2.46e+07
cbd2b+cgs3_xo1_x1 0 205 2.174e-13
gm3_xo1_x1 103 0 205 0 0.000406
rds3+rds4+rl_xo1_x1 103 0 3469.05
cbd3+cbd4+cgd4+cl_xo1_x1 0 103 1.04677e-11
rds5_xo1_x1 203 0 4.695e+07
cbd5_xo1_x1 0 203 2.45e-14
cc_xo1_x1 205 103 1e-12
gm1a_xo2_x1 304 303 104 303 5.89e-06
rds1a_xo2_x1 304 303 9.26e+07
cbd1a_xo2_x1 303 304 2.04e-14
cgs1a_xo2_x1 104 303 4.78e-14
gm1b_xo2_x1 305 303 0 303 5.89e-06
rds1b_xo2_x1 305 303 9.26e+07
cbd1b_xo2_x1 303 305 2.04e-14
cgs1b_xo2+cbd5_xo2_x1 0 303 7.23e-14
gm2a_xo2_x1 304 0 304 0 3e-05
rds2a_xo2_x1 304 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo2_x1 0 304 1.1164e-12
gm2b_xo2_x1 305 0 304 0 3e-05
rds2b_xo2_x1 305 0 2.46e+07
cbd2b+cgs3_xo2_x1 0 305 2.174e-13
gm3_xo2_x1 2 0 305 0 0.000406
rds3+rds4+rl_xo2_x1 2 0 3469.05
cbd3+cbd4+cgd4+cl_xo2_x1 0 2 1.04677e-11
rds5_xo2_x1 303 0 4.695e+07
cc_xo2_x1 305 2 1e-12
gm1a_xo3_x1 404 403 106 403 5.89e-06
rds1a_xo3_x1 404 403 9.26e+07
cbd1a_xo3_x1 403 404 2.04e-14
cgs1a_xo3_x1 106 403 4.78e-14
gm1b_xo3_x1 405 403 0 403 5.89e-06
rds1b_xo3_x1 405 403 9.26e+07
cbd1b_xo3_x1 403 405 2.04e-14
cgs1b_xo3+cbd5_xo3_x1 0 403 7.23e-14
gm2a_xo3_x1 404 0 404 0 3e-05
rds2a_xo3_x1 404 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo3_x1 0 404 1.1164e-12
gm2b_xo3_x1 405 0 404 0 3e-05
rds2b_xo3_x1 405 0 2.46e+07
cbd2b+cgs3_xo3_x1 0 405 2.174e-13
gm3_xo3_x1 107 0 405 0 0.000406
rds3+rds4+rl_xo3_x1 107 0 3469.05
cbd3+cbd4+cgd4+cl_xo3_x1 0 107 1.04677e-11
rds5_xo3_x1 403 0 4.695e+07
cc_xo3_x1 405 107 1e-12
r1_x2 2 202 1
r2_x2 3 208 1
r3_x2 202 0 1
r4_x2 208 203 1
r5_x2 203 204 1
r6_x2 204 4 1
c6_x2 204 4 1
r7_x2 4 206 1
c8_x2 206 207 1
r9_x2 207 208 1
gm1a_xo1_x2 304 303 208 303 5.89e-06
rds1a_xo1_x2 304 303 9.26e+07
cbd1a_xo1_x2 303 304 2.04e-14
cgs1a_xo1_x2 208 303 4.78e-14
gm1b_xo1_x2 305 303 202 303 5.89e-06
rds1b_xo1_x2 305 303 9.26e+07
cbd1b_xo1_x2 303 305 2.04e-14
cgs1b_xo1_x2 202 303 4.78e-14
gm2a_xo1_x2 304 0 304 0 3e-05
rds2a_xo1_x2 304 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo1_x2 0 304 1.1164e-12
gm2b_xo1_x2 305 0 304 0 3e-05
rds2b_xo1_x2 305 0 2.46e+07
cbd2b+cgs3_xo1_x2 0 305 2.174e-13
gm3_xo1_x2 203 0 305 0 0.000406
rds3+rds4+rl_xo1_x2 203 0 3469.05
cbd3+cbd4+cgd4+cl_xo1_x2 0 203 1.04677e-11
rds5_xo1_x2 303 0 4.695e+07
cbd5_xo1_x2 0 303 2.45e-14
cc_xo1_x2 305 203 1e-12
gm1a_xo2_x2 404 403 204 403 5.89e-06
rds1a_xo2_x2 404 403 9.26e+07
cbd1a_xo2_x2 403 404 2.04e-14
cgs1a_xo2_x2 204 403 4.78e-14
gm1b_xo2_x2 405 403 0 403 5.89e-06
rds1b_xo2_x2 405 403 9.26e+07
cbd1b_xo2_x2 403 405 2.04e-14
cgs1b_xo2+cbd5_xo2_x2 0 403 7.23e-14
gm2a_xo2_x2 404 0 404 0 3e-05
rds2a_xo2_x2 404 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo2_x2 0 404 1.1164e-12
gm2b_xo2_x2 405 0 404 0 3e-05
rds2b_xo2_x2 405 0 2.46e+07
cbd2b+cgs3_xo2_x2 0 405 2.174e-13
gm3_xo2_x2 4 0 405 0 0.000406
rds3+rds4+rl_xo2_x2 4 0 3469.05
cbd3+cbd4+cgd4+cl_xo2_x2 0 4 1.04677e-11
rds5_xo2_x2 403 0 4.695e+07
cc_xo2_x2 405 4 1e-12
gm1a_xo3_x2 504 503 206 503 5.89e-06
rds1a_xo3_x2 504 503 9.26e+07
cbd1a_xo3_x2 503 504 2.04e-14
cgs1a_xo3_x2 206 503 4.78e-14
gm1b_xo3_x2 505 503 0 503 5.89e-06
rds1b_xo3_x2 505 503 9.26e+07
cbd1b_xo3_x2 503 505 2.04e-14
cgs1b_xo3+cbd5_xo3_x2 0 503 7.23e-14
gm2a_xo3_x2 504 0 504 0 3e-05
rds2a_xo3_x2 504 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo3_x2 0 504 1.1164e-12
gm2b_xo3_x2 505 0 504 0 3e-05
rds2b_xo3_x2 505 0 2.46e+07
cbd2b+cgs3_xo3_x2 0 505 2.174e-13
gm3_xo3_x2 207 0 505 0 0.000406
rds3+rds4+rl_xo3_x2 207 0 3469.05
cbd3+cbd4+cgd4+cl_xo3_x2 0 207 1.04677e-11
rds5_xo3_x2 503 0 4.695e+07
cc_xo3_x2 505 207 1e-12
r1_x3 4 302 1
r2_x3 5 308 1
r3_x3 302 0 1
r4_x3 308 303 1
r5_x3 303 304 1
r6_x3 304 3 1
c6_x3 304 3 1
r7_x3 3 306 1
c8_x3 306 307 1
r9_x3 307 308 1
gm1a_xo1_x3 404 403 308 403 5.89e-06
rds1a_xo1_x3 404 403 9.26e+07
cbd1a_xo1_x3 403 404 2.04e-14
cgs1a_xo1_x3 308 403 4.78e-14
gm1b_xo1_x3 405 403 302 403 5.89e-06
rds1b_xo1_x3 405 403 9.26e+07
cbd1b_xo1_x3 403 405 2.04e-14
cgs1b_xo1_x3 302 403 4.78e-14
gm2a_xo1_x3 404 0 404 0 3e-05
rds2a_xo1_x3 404 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo1_x3 0 404 1.1164e-12
gm2b_xo1_x3 405 0 404 0 3e-05
rds2b_xo1_x3 405 0 2.46e+07
cbd2b+cgs3_xo1_x3 0 405 2.174e-13
gm3_xo1_x3 303 0 405 0 0.000406
rds3+rds4+rl_xo1_x3 303 0 3469.05
cbd3+cbd4+cgd4+cl_xo1_x3 0 303 1.04677e-11
rds5_xo1_x3 403 0 4.695e+07
cbd5_xo1_x3 0 403 2.45e-14
cc_xo1_x3 405 303 1e-12

r1_x4 3 402 1
r2_x4 8 408 1
r3_x4 402 0 1
r4_x4 408 403 1
r5_x4 403 404 1
r6_x4 404 5 1
c6_x4 404 5 1
r7_x4 5 406 1
c8_x4 406 407 1
r9_x4 407 408 1
gm1a_xo1_x4 504 503 408 503 5.89e-06
rds1a_xo1_x4 504 503 9.26e+07
cbd1a_xo1_x4 503 504 2.04e-14
cgs1a_xo1_x4 408 503 4.78e-14
gm1b_xo1_x4 505 503 402 503 5.89e-06
rds1b_xo1_x4 505 503 9.26e+07
cbd1b_xo1_x4 503 505 2.04e-14
cgs1b_xo1_x4 402 503 4.78e-14
gm2a_xo1_x4 504 0 504 0 3e-05
rds2a_xo1_x4 504 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo1_x4 0 504 1.1164e-12
gm2b_xo1_x4 505 0 504 0 3e-05
rds2b_xo1_x4 505 0 2.46e+07
cbd2b+cgs3_xo1_x4 0 505 2.174e-13
gm3_xo1_x4 403 0 505 0 0.000406
rds3+rds4+rl_xo1_x4 403 0 3469.05
cbd3+cbd4+cgd4+cl_xo1_x4 0 403 1.04677e-11
rds5_xo1_x4 503 0 4.695e+07
cbd5_xo1_x4 0 503 2.45e-14
cc_xo1_x4 505 403 1e-12
gm1a_xo2_x4 604 603 404 603 5.89e-06
rds1a_xo2_x4 604 603 9.26e+07
cbd1a_xo2_x4 603 604 2.04e-14
cgs1a_xo2_x4 404 603 4.78e-14
gm1b_xo2_x4 605 603 0 603 5.89e-06
rds1b_xo2_x4 605 603 9.26e+07
cbd1b_xo2_x4 603 605 2.04e-14
cgs1b_xo2+cbd5_xo2_x4 0 603 7.23e-14
gm2a_xo2_x4 604 0 604 0 3e-05
rds2a_xo2_x4 604 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo2_x4 0 604 1.1164e-12
gm2b_xo2_x4 605 0 604 0 3e-05
rds2b_xo2_x4 605 0 2.46e+07
cbd2b+cgs3_xo2_x4 0 605 2.174e-13
gm3_xo2_x4 5 0 605 0 0.000406
rds3+rds4+rl_xo2_x4 5 0 3469.05
cbd3+cbd4+cgd4+cl_xo2_x4 0 5 1.04677e-11
rds5_xo2_x4 603 0 4.695e+07
cc_xo2_x4 605 5 1e-12
gm1a_xo3_x4 704 703 406 703 5.89e-06
rds1a_xo3_x4 704 703 9.26e+07
cbd1a_xo3_x4 703 704 2.04e-14
cgs1a_xo3_x4 406 703 4.78e-14
gm1b_xo3_x4 705 703 0 703 5.89e-06
rds1b_xo3_x4 705 703 9.26e+07
cbd1b_xo3_x4 703 705 2.04e-14
cgs1b_xo3+cbd5_xo3_x4 0 703 7.23e-14
gm2a_xo3_x4 704 0 704 0 3e-05
rds2a_xo3_x4 704 0 2.46e+07
cbd2a+cgs2a+cgs2b_xo3_x4 0 704 1.1164e-12
gm2b_xo3_x4 705 0 704 0 3e-05
rds2b_xo3_x4 705 0 2.46e+07
cbd2b+cgs3_xo3_x4 0 705 2.174e-13
gm3_xo3_x4 407 0 705 0 0.000406
rds3+rds4+rl_xo3_x4 407 0 3469.05
cbd3+cbd4+cgd4+cl_xo3_x4 0 407 1.04677e-11
rds5_xo3_x4 703 0 4.695e+07
cc_xo3_x4 705 407 1e-12
gm1a_x5 504 503 6 503 5.89e-06
rds1a_x5 504 503 9.26e+07
cbd1a_x5 503 504 2.04e-14
cgs1a_x5 6 503 4.78e-14
gm1b_x5 505 503 7 503 5.89e-06
rds1b_x5 505 503 9.26e+07
cbd1b_x5 503 505 2.04e-14
cgs1b_x5 7 503 4.78e-14
gm2a_x5 504 0 504 0 3e-05
rds2a_x5 504 0 2.46e+07
cbd2a+cgs2a+cgs2b_x5 0 504 1.1164e-12
gm2b_x5 505 0 504 0 3e-05
rds2b_x5 505 0 2.46e+07
cbd2b+cgs3_x5 0 505 2.174e-13
gm3_x5 8 0 505 0 0.000406
rds3+rds4+rl_x5 8 0 3469.05
cbd3+cbd4+cgd4+cl_x5 0 8 1.04677e-11
rds5_x5 503 0 4.695e+07
cbd5_x5 0 503 2.45e-14
cc_x5 505 8 1e-12

gm1a_x5 504 503 6 503 5.89e-06
rds1a_x5 504 503 9.26e+07
cbd1a_x5 503 504 2.04e-14
cgs1a_x5 6 503 4.78e-14
gm1b_x5 505 503 7 503 5.89e-06
rds1b_x5 505 503 9.26e+07
cbd1b_x5 503 505 2.04e-14
cgs1b_x5 7 503 4.78e-14
gm2a_x5 504 0 504 0 3e-05
rds2a_x5 504 0 2.46e+07
cbd2a+cgs2a+cgs2b_x5 0 504 1.1164e-12
gm2b_x5 505 0 504 0 3e-05
rds2b_x5 505 0 2.46e+07
cbd2b+cgs3_x5 0 505 2.174e-13
gm3_x5 8 0 505 0 0.000406
rds3+rds4+rl_x5 8 0 3469.05
cbd3+cbd4+cgd4+cl_x5 0 8 1.04677e-11
rds5_x5 503 0 4.695e+07
cbd5_x5 0 503 2.45e-14
cc_x5 505 8 1e-12

vin 1 0 dc 0 ac 1
.ac dec 1 1 10meg
.print vdb(8)
.end
